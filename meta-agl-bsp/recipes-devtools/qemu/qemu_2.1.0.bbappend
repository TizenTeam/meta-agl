FILESEXTRAPATHS_prepend := "${THISDIR}/qemu:"

SRC_URI += "file://add_virtio_gpu_core_code.patch"
